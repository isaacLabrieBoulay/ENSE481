# Keil uVision project lab3_pwm.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab4_adc
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: .\app;.\cli;.\drivers
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./app/: app.c app.h main.c time_opps.c time_opps.h time_trig_ops.c time_trig_ops.h
  group cli
    ./cli/: CLI.c CLI.h
  group drivers
    ./drivers/: drivers.c drivers.h timer.h timer_impl.c pwm.h pwm.c
software components: CMSIS:CORE 5.6.0, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0
