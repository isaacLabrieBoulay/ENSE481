# Keil uVision project final_project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: final_project
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\app;.\cli;.\drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./app/: app.h time_opps.h time_trig_ops.h app.c main.c time_opps.c time_trig_ops.c
    ./cli/: CLI.c
    ./drivers/: drivers.c pwm.c timer_impl.c
    ./: PID.c PID.h
software components: CMSIS:CORE 5.6.0, Compiler:Event Recorder 1.5.1, Device:GPIO 1.3, Device:Startup 1.0.0
